Commit message: [DCL-105] PDB release planner implemented

File: entity_files/drop_scenario/hoop_large.urdf (robot description, URDF)
Before this commit: robot debug_cube, 1 links, 0 joints
Links:
- link cube_obj: geometry visual box size=0.05 0.05 0.9; visual box size=0.05 0.05 0.9
